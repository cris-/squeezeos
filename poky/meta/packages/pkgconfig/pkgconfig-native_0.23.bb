require pkgconfig.inc
inherit native
DEPENDS = ""

BUILD_OPTIMIZATION = " "
