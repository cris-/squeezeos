require automake-native.inc

SRC_URI += "file://perl.patch;patch=1"
